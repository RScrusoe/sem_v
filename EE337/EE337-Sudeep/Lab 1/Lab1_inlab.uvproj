# Keil uVision project Lab1_inlab.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Lab1_inlab
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adder16.asm
  group New Group
    ./: sub16.asm

ORG 00H
LJMP MAIN
ORG 0200H


CONVERT:

	MOV A, @R0
	ANL A, #0FH
	MOV R2, A
	LJMP COMPAREL
	
	HIGHER:
			MOV A, @R0
			SWAP A
			ANL A, #0FH
			MOV R3, A
			LJMP COMPAREH	
	LAST_STEP:
	MOV A, R3
	MOV @R1,A
	INC R1
	MOV A, R2
	MOV @R1,A
	INC R1
	INC R0
	DJNZ 50H, CONVERT
	RET
	
COMPAREL:
	MOV A, #09H
	CLR C
	SUBB A,  R2
	
	JNC BLOCK1L
	
	MOV A, R2
	ADD A, #37H
	 
	MOV R2, A
	LJMP HIGHER
	
BLOCK1L:
	MOV A, R2
	ADD A, #30H
	MOV R2, A
	LJMP HIGHER
	

COMPAREH:
	MOV A, #09H
	CLR C
	SUBB A,  R3
	
	JNC BLOCK1H
	
	MOV A, R3
	ADD A, #37H 
	MOV R3, A
	LJMP LAST_STEP
	
BLOCK1H:
	MOV A, R3
	ADD A, #30H
	MOV R3, A
	LJMP LAST_STEP


	

MAIN:
	MOV 50H, #5H
	MOV 51H, #53H
	MOV A, 50H
	ADD A, 51H
	MOV 52H, A	
	MOV R0, 51H
	MOV R1, 52H
	MOV 53H, #0ABH
	MOV 54H, #0CDH
	MOV 55H, #0E6H
	MOV 56H, #09FH
	MOV 57H, #00DH
	ACALL CONVERT
	STOP: SJMP STOP
	
END
ORG 00H
LJMP MAIN
ORG 0200H

MEMCPY:
	MOV A, @R1
	MOV @R0, A
	INC R1
	INC R0
	DJNZ R2, MEMCPY
	RET
	


MAIN:
	MOV 50H, #6H
	MOV R2, 50H
	MOV 51H, #60H
	MOV 52H, #63H
	MOV A, 52H
	ADD A, 50H
	MOV R0, A
	MOV R1, 51H
	
	ACALL MEMCPY

	MOV A, 52H
	ADD A, 50H
	MOV R1, A
	MOV R0, 52H
	MOV R2, 50H
	
	ACALL MEMCPY
	
		
	STOP: SJMP STOP
	
END
	